Commit message: nn01
first learning step

File: urdf/01-myfirst.urdf (robot description, URDF)
Before this commit: robot myfirst, 1 links, 0 joints
Links:
- removed link base_link
- added link L1; visual cylinder length=0.6 radius=0.2
